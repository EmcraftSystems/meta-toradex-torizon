require trusted-firmware-a-secboot.inc
